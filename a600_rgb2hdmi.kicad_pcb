File: a600_rgb2hdmi.kicad_pcb (KiCad board)
At the start: 2 copper layers, 55.5 x 38.6 mm, 4 parts

Commit message: updated BOM
Other:
- net class Default removed
